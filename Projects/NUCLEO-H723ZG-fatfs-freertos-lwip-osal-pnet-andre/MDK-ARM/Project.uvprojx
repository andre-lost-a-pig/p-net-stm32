# Keil uVision project Project.uvprojx, settings and files
target STM32H723ZG_Nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.3
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H723ZG_NUCLEO
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,Debug
  c misc: --C99 --gnu
  c include: ../Inc;../../../Drivers/BSP/STM32H7xx_Nucleo;../../../Drivers/CMSIS/Include;../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../Drivers/BSP/Components/Common;../../../Utilities/Fonts;../../../Utilities/CPU;..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;../../../Middlewares/Third_Party/LwIP/system;../../../Middlewares/Third_Party/LwIP/src/include/;../Src;..\..\..\Middlewares\Third_Party\osal\include;..\..\..\Middlewares\Third_Party\osal\src\freertos;..\Inc\pn_dev;..\..\..\Middlewares\Third_Party\p-net\include;..\..\..\Middlewares\Third_Party\p-net\src;..\..\..\Middlewares\Third_Party\p-net\src\common;..\..\..\Middlewares\Third_Party\p-net\src\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: STM32H723ZG_Nucleo\Exe\STM32H723ZG_NUCLEO.sct
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Example/User
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c ethernetif.c stm32h7xx_hal_timebase_tim.c app_ethernet.c httpserver_socket.c
  group Example/MDK-ARM
    ./: startup_stm32h723xx.s
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/BSP/STM32H7xx_Nucleo
    ../../../Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_eth.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_eth_ex.c
  group Middlewares/FatFs/Core
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c queue.c timers.c tasks.c event_groups.c list.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/FreeRTOS/portable
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP/Core
    ../../../Middlewares/Third_Party/LwIP/src/core/: raw.c memp.c inet_chksum.c tcp.c def.c mem.c ip.c netif.c stats.c udp.c pbuf.c sys.c tcp_in.c tcp_out.c timeouts.c dns.c init.c
  group Middlewares/LwIP/Core/IPv4
    ../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c etharp.c ip4.c autoip.c ip4_addr.c ip4_frag.c dhcp.c igmp.c
  group Middlewares/LwIP/Api
    ../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Netif
    ../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/LwIP/apps/http
    ../../../Middlewares/Third_Party/LwIP/src/apps/http/: httpd.c fs.c
  group Middlewares/osal
    ../../../Middlewares/Third_Party/osal/src/freertos/: osal.c osal_log.c
  group Example/pn_dev
    ../Src/pn_dev/: app_data.c app_gsdml.c app_log.c app_utils.c pnal.c pnal_eth.c pnal_udp.c sampleapp_common.c sampleapp_main.c sampleapp_NUCLEO-H723ZG.c
  group Middlewares/p-net/device
    ../../../Middlewares/Third_Party/p-net/src/device/: pf_block_reader.c pf_block_writer.c pf_cmdev.c pf_cmdmc.c pf_cmina.c pf_cmio.c pf_cmpbe.c pf_cmrdr.c pf_cmrpc.c pf_cmrpc_epm.c pf_cmrpc_helpers.c pf_cmrs.c pf_cmsm.c pf_cmsu.c pf_cmwrr.c pf_diag.c pf_fspm.c pf_pdport.c pf_port.c pnet_api.c
  group Middlewares/p-net/common
    ../../../Middlewares/Third_Party/p-net/src/common/: pf_alarm.c pf_bg_worker.c pf_cpm.c pf_cpm_driver_sw.c pf_dcp.c pf_eth.c pf_file.c pf_lldp.c pf_ppm.c pf_ppm_driver_sw.c pf_ptcp.c pf_scheduler.c pf_udp.c
